options:
  parameters:
    author: rob+kb5mu
    generate_options: qt_gui
    id: OPV_impaired
    output_language: python
    title: OPV_impaired
  states: {}

blocks:
- name: deviation
  id: variable
  parameters:
    comment: Unit of deviation in Hz (this * symbol value is symbol deviation in Hz)
    value: '4000'
  states: {}
- name: interpolation_rate
  id: variable
  parameters:
    value: '128'
  states: {}
- name: lo_frequency
  id: variable
  parameters:
    value: 905050000+7750
  states: {}
- name: sample_rate
  id: variable
  parameters:
    comment: This must be at least 512k for PlutoSDR
    value: symbol_rate * interpolation_rate
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '18700'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: deviation * 2 * 3.141592 / sample_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./MDT-ORI-Intro.bit
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: '0'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_selective_fading_model_0
  id: channels_selective_fading_model
  parameters:
    K: '4.0'
    LOS: 'True'
    N: '8'
    delays: (0.0,0.1,1.3)
    fDTs: 10.0/sample_rate
    mags: (1,0.99,0.97)
    ntaps: '12'
    seed: '0'
  states: {state: bypassed}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[+1.0,+3.0,-1.0,-3.0]'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '30.0'
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: lo_frequency
    samplerate: sample_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: sample_rate
    type: complex
    ymax: '6'
    ymin: '-6'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: interpolation_rate
    interp: interpolation_rate
    ntaps: interpolation_rate*11+1
    samp_rate: interpolation_rate
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', channels_selective_fading_model_0, '0']
- [blocks_file_source_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [channels_channel_model_0, '0', iio_pluto_sink_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_0, '0']
- [channels_selective_fading_model_0, '0', channels_channel_model_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [root_raised_cosine_filter_0, '0', analog_frequency_modulator_fc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
